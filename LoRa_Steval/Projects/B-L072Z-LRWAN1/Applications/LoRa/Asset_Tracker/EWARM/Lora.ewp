# IAR project Lora.ewp, settings and files
configuration mlm32l07x01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_B_L072Z_LRWAN1; REGION_EU868; IOT_TRACKER_APP_VER=0x00002200; STM32L072xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/BSP/CMWX1ZZABZ-0xx; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/teseoIII; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Drivers/BSP/Components/gnss; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1; ../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region; ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Inc; ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mlm32l07x01.bin
  ILINK.IlinkOutputFile: mlm32l07x01.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/CMWX1ZZABZ-0xx
    ../../../../../../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
  group Drivers/BSP/TeseoIII
    ../../../../../../Drivers/BSP/Components/teseoIII/: teseo_i2c.c teseo_io.c teseo_queue.c teseo_uart.c
  group Drivers/BSP/X-NUCLEO-GNSS1A1
    ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1/: x_nucleo_gnss1a1.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: iks01a2_env_sensors.c iks01a2_env_sensors_ex.c iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/LoRaWAN/Crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
  group Middlewares/LoRaWAN/Mac
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWAN/Patterns/Basic
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic/: lora-test.c lora.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c
  group Middlewares/STM32_GNSS/LibGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Src/: gnss_data.c gnss_parser.c
  group Middlewares/STM32_GNSS/LibNMEA
    ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Src/: NMEA_parser.c
  group Projects/Asset_Tracker
    ../LoRaWAN/App/src/: bsp.c command.c config_bus.c debug.c gnss_if.c hw_gpio.c hw_rtc.c hw_spi.c log_manager.c main.c nucleo_l053r8_bus.c usb_user.c vcom.c
    ../Core/src/: mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Projects/EWARM
    ./: startup_stm32l072xx.s
